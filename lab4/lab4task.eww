<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Lab 4 - 14.11 ver 2\Lab4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\Lab 4 - tast 18.11\lab4tast.ewp</path>
  </project>
  <batchBuild/>
</workspace>


